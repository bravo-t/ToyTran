.lib circuits/INVx2_ASAP7_75t_R.dat
VVdd POS GND pwl(
  0 0
  10ps 0.77)
Xdriver INVx2_ASAP7_75t_R A POS Y N1
CC1 N1 GND 1E-14
RR1 N1 N2 1000
CC2 N2 GND 1E-14
Xloader INVx2_ASAP7_75t_R A N2 Y GND

.delay Xdriver/A Xloader/A
.option driver=rampvoltage loader=fixed
.debug 1
