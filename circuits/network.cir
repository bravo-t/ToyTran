VVDD Driver 0 5
R1 Driver NET:212 26.6268
R2 0/018CK NET:78 6.04435
R3 0/019CK NET:73 12.4392
R4 0/09CK NET:194 26.54
R5 0/118CK NET:80 6.04435
R6 0/124CK NET:84 6.04435
R7 0/19CK NET:181 10.0232
R8 0/218CK NET:177 7.60134
R9 0/224CK NET:75 6.0359
R10 0/25CK NET:205 7.59063
R11 0/29CK NET:183 6.04435
R12 0/316CK NET:196 6.04125
R13 0/324CK NET:82 8.28048
R14 0/36CK NET:209 6.0359
R15 0/37CK NET:175 6.04125
R16 0/39CK NET:181 34.0188
R17 0/in1CK NET:48 15.2012
R18 0/in10CK NET:64 18.2092
R19 0/in11CK NET:2 13.5527
R20 0/in12CK NET:37 6.88703
R21 0/in16CK NET:62 8.28584
R22 0/in17CK NET:35 23.1891
R23 0/in19CK NET:33 6.04435
R24 0/in2CK NET:45 6.90264
R25 0/in20CK NET:43 6.04435
R26 0/in21CK NET:12 6.04125
R27 0/in24CK NET:21 6.04125
R28 0/in3CK NET:53 6.90264
R29 0/in4CK NET:47 6.04125
R30 0/in7CK NET:63 10.659
R31 0/in9CK NET:30 6.91369
R32 1/in10CK NET:201 12.1239
R33 1/in13CK NET:207 6.81705
R34 1/in14CK NET:186 6.91898
R35 1/in15CK NET:191 7.60134
R36 1/in16CK NET:198 6.04435
R37 1/in17CK NET:188 3.80067
R38 1/in18CK NET:171 23.1622
R39 1/in19CK NET:66 29.8851
R40 1/in20CK NET:199 35.7494
R41 1/in21CK NET:184 25.2635
R42 2/010CK NET:89 3.80067
R43 2/011CK NET:96 3.80067
R44 2/012CK NET:28 26.3862
R45 2/013CK NET:104 33.8354
R46 2/016CK NET:94 5.701
R47 2/017CK NET:106 16.6291
R48 2/018CK NET:107 10.02
R49 2/06CK NET:26 13.5436
R50 2/07CK NET:151 12.4695
R51 2/09CK NET:105 10.018
R52 2/110CK NET:108 24.9056
R53 2/112CK NET:101 6.92284
R54 2/113CK NET:154 12.4478
R55 2/117CK NET:117 7.60134
R56 2/16CK NET:134 3.80067
R57 2/17CK NET:150 24.0609
R58 2/210CK NET:166 10.5863
R59 2/211CK NET:112 6.89149
R60 2/212CK NET:161 31.1937
R61 2/213CK NET:136 6.04125
R62 2/215CK NET:104 20.6336
R63 2/216CK NET:69 7.60134
R64 2/217CK NET:140 13.3373
R65 2/220CK NET:164 10.9732
R66 2/221CK NET:158 3.80067
R67 2/26CK NET:144 13.781
R68 2/310CK NET:110 3.80067
R69 2/312CK NET:165 27.5549
R70 2/316CK NET:86 6.04435
R71 2/317CK NET:87 25.4169
R72 2/321CK NET:163 6.04435
R73 2/36CK NET:132 21.5832
R74 2/37CK NET:147 7.60134
R75 2/39CK NET:150 15.3213
R76 2/in0CK NET:167 24.8099
R77 2/in1CK NET:14 6.04125
R78 2/in10CK NET:119 7.60134
R79 2/in11CK NET:126 6.04125
R80 2/in12CK NET:57 16.8204
R81 2/in14CK NET:58 13.7515
R82 2/in15CK NET:57 18.6358
R83 2/in17CK NET:128 6.04125
R84 2/in18CK NET:121 5.701
R85 2/in2CK NET:39 6.90283
R86 2/in20CK NET:51 6.04125
R87 2/in21CK NET:18 6.04125
R88 2/in24CK NET:160 3.80067
R89 2/in3CK NET:124 23.956
R90 2/in4CK NET:6 36.0876
R91 2/in5CK NET:26 19.7838
R92 2/in6CK NET:131 6.91369
R93 2/in7CK NET:23 3.80067
R94 2/in8CK NET:27 20.9544
R95 2/in9CK NET:61 16.5752
R96 NET:178 NET:184 235.542
R97 NET:178 NET:181 8.61275
R98 NET:178 NET:173 72.0454
R99 NET:178 NET:175 520.929
R100 NET:178 NET:177 38.5615
R101 NET:178 NET:183 29.5811
R102 NET:194 NET:196 71.4584
R103 NET:194 NET:198 36.9384
R104 NET:194 NET:199 38.9073
R105 NET:200 NET:201 2.43236
R106 NET:200 NET:191 38.387
R107 NET:200 NET:199 40.3679
R108 NET:201 NET:202 23.806
R109 NET:201 NET:205 1005.07
R110 NET:201 NET:210 814.757
R111 NET:171 NET:184 176.268
R112 NET:171 NET:211 37.0264
R113 NET:184 NET:181 738.677
R114 NET:184 NET:183 153.596
R115 NET:184 NET:211 11.7259
R116 NET:73 NET:82 62.9112
R117 NET:73 NET:75 641.664
R118 NET:73 NET:81 88.3715
R119 NET:65 NET:66 3.7701
R120 NET:65 NET:2 163.657
R121 NET:65 NET:3 2.9454
R122 NET:65 NET:64 211.792
R123 NET:66 NET:169 19.4007
R124 NET:169 NET:212 26.8076
R125 NET:169 NET:67 29.6526
R126 NET:169 NET:188 301.368
R127 NET:169 NET:69 475.042
R128 NET:169 NET:211 47.5577
R129 NET:169 NET:168 577.307
R130 NET:212 NET:211 582.48
R131 NET:2 NET:3 80.9504
R132 NET:2 NET:64 7.15723
R133 NET:90 NET:87 50.019
R134 NET:90 NET:89 34.7567
R135 NET:90 NET:168 1.92946
R136 NET:87 NET:82 150.316
R137 NET:87 NET:84 472.2
R138 NET:87 NET:86 83.3641
R139 NET:87 NET:89 34.3152
R140 NET:6 NET:63 4.57587
R141 NET:6 NET:64 53.5025
R142 NET:113 NET:108 26.6681
R143 NET:113 NET:110 35.7153
R144 NET:113 NET:112 20.1168
R145 NET:113 NET:168 45.5186
R146 NET:113 NET:140 46.153
R147 NET:113 NET:167 27.2178
R148 NET:108 NET:107 44.1127
R149 NET:108 NET:110 36.0052
R150 NET:108 NET:112 162.928
R151 NET:8 NET:63 94.8403
R152 NET:8 NET:62 4.69507
R153 NET:8 NET:12 9.20941
R154 NET:144 NET:166 6.64622
R155 NET:144 NET:151 41.6583
R156 NET:144 NET:165 121.912
R157 NET:124 NET:129 6.22592
R158 NET:124 NET:126 17.4219
R159 NET:124 NET:128 130.689
R160 NET:132 NET:129 17.5317
R161 NET:132 NET:131 345.525
R162 NET:132 NET:137 1.92946
R163 NET:129 NET:131 8.87126
R164 NET:129 NET:126 21.1411
R165 NET:129 NET:128 158.588
R166 NET:10 NET:62 43.3663
R167 NET:10 NET:14 8.37678
R168 NET:10 NET:61 27.4408
R169 NET:31 NET:28 36.6946
R170 NET:31 NET:33 69.1637
R171 NET:31 NET:30 42.5924
R172 NET:31 NET:61 59.7801
R173 NET:31 NET:60 20.2122
R174 NET:28 NET:30 14.8125
R175 NET:28 NET:18 11.6984
R176 NET:28 NET:27 32.4573
R177 NET:154 NET:165 72.6006
R178 NET:154 NET:164 43.0053
R179 NET:161 NET:163 87.3822
R180 NET:161 NET:158 37.4605
R181 NET:161 NET:160 53.3044
R182 NET:161 NET:164 12.4309
R183 NET:35 NET:60 14.9149
R184 NET:35 NET:59 18.4314
R185 NET:57 NET:58 5.07094
R186 NET:40 NET:49 3.32296
R187 NET:40 NET:59 95.7012
R188 NET:40 NET:48 7.60083
R189 NET:181 NET:183 92.7686
R190 NET:173 NET:175 6.45299
R191 NET:173 NET:177 16.9476
R192 NET:76 NET:78 3.38095
R193 NET:76 NET:80 35.4341
R194 NET:76 NET:81 93.842
R195 NET:202 NET:205 43.2839
R196 NET:202 NET:210 35.088
R197 NET:203 NET:207 53.0278
R198 NET:203 NET:209 9.44925
R199 NET:203 NET:210 47.0397
R200 NET:3 NET:64 104.76
R201 NET:67 NET:69 16.9379
R202 NET:67 NET:168 72.3783
R203 NET:82 NET:75 25.2794
R204 NET:82 NET:84 14.7575
R205 NET:82 NET:86 35.4
R206 NET:82 NET:81 99.1441
R207 NET:63 NET:62 28.9946
R208 NET:63 NET:64 68.8069
R209 NET:115 NET:117 3.90049
R210 NET:115 NET:140 32.2803
R211 NET:115 NET:139 66.8663
R212 NET:138 NET:119 41.3596
R213 NET:138 NET:121 37.7932
R214 NET:138 NET:139 1.92946
R215 NET:138 NET:137 37.1961
R216 NET:62 NET:12 139.837
R217 NET:62 NET:14 1257.33
R218 NET:62 NET:61 269.139
R219 NET:107 NET:94 17.5605
R220 NET:107 NET:96 35.135
R221 NET:107 NET:106 48.27
R222 NET:166 NET:167 0.438564
R223 NET:166 NET:151 92.9204
R224 NET:166 NET:165 271.929
R225 NET:105 NET:99 120.579
R226 NET:105 NET:101 680.932
R227 NET:105 NET:106 1.34838
R228 NET:105 NET:104 21.2181
R229 NET:99 NET:101 10.9937
R230 NET:99 NET:104 40.7592
R231 NET:49 NET:59 39.0251
R232 NET:49 NET:48 82.4734
R233 NET:175 NET:177 122.541
R234 NET:196 NET:198 54.2451
R235 NET:196 NET:199 16.633
R236 NET:198 NET:199 29.5351
R237 NET:191 NET:199 6.70277
R238 NET:78 NET:80 118.012
R239 NET:78 NET:81 312.537
R240 NET:80 NET:81 17.8423
R241 NET:205 NET:210 27.363
R242 NET:207 NET:209 454.044
R243 NET:207 NET:210 20.2948
R244 NET:186 NET:210 27.4316
R245 NET:186 NET:211 36.5754
R246 NET:209 NET:210 402.772
R247 NET:188 NET:211 5.22083
R248 NET:75 NET:81 1011.22
R249 NET:84 NET:86 111.205
R250 NET:69 NET:168 1159.52
R251 NET:117 NET:140 127.488
R252 NET:117 NET:139 264.081
R253 NET:110 NET:112 218.201
R254 NET:119 NET:121 30.4897
R255 NET:119 NET:137 58.8225
R256 NET:94 NET:96 290.416
R257 NET:94 NET:106 398.986
R258 NET:121 NET:137 53.7503
R259 NET:96 NET:106 275.424
R260 NET:126 NET:128 28.0986
R261 NET:147 NET:151 37.7498
R262 NET:147 NET:150 12.5833
R263 NET:134 NET:136 38.0707
R264 NET:134 NET:137 18.2546
R265 NET:14 NET:61 795.599
R266 NET:136 NET:137 98.5151
R267 NET:101 NET:104 230.174
R268 NET:33 NET:61 42.2388
R269 NET:33 NET:60 611.766
R270 NET:18 NET:27 11.7269
R271 NET:37 NET:39 45.2218
R272 NET:37 NET:60 21.6471
R273 NET:21 NET:23 81.9696
R274 NET:21 NET:27 7.98513
R275 NET:21 NET:26 37.7553
R276 NET:23 NET:27 158.995
R277 NET:23 NET:26 16.9046
R278 NET:39 NET:60 19.4537
R279 NET:163 NET:164 18.339
R280 NET:158 NET:160 17.4659
R281 NET:51 NET:53 77.2063
R282 NET:51 NET:59 18.3486
R283 NET:51 NET:58 25.6939
R284 NET:53 NET:59 12.1776
R285 NET:53 NET:58 116.473
R286 NET:43 NET:45 172.533
R287 NET:43 NET:47 56.7378
R288 NET:43 NET:48 35.8434
R289 NET:45 NET:47 62.4129
R290 NET:45 NET:48 14.0676
R291 NET:47 NET:48 12.9662
R292 NET:210 NET:211 5.70545
R293 NET:168 NET:140 919.951
R294 NET:168 NET:167 542.524
R295 NET:140 NET:139 7.92778
R296 NET:140 NET:167 38.9134
R297 NET:151 NET:150 7.74207
R298 NET:151 NET:165 135.447
R299 NET:61 NET:60 528.766
R300 NET:165 NET:164 82.9868
R301 NET:27 NET:26 73.2333
R302 NET:60 NET:59 109.13
R303 NET:59 NET:58 27.6805
C1 1/in19CK 0 1.33978e-16
C2 0/in11CK 0 2.14319e-17
C3 NET:2 0 6.56551e-17
C4 NET:3 0 2.95243e-16
C5 0/in10CK 0 3.02914e-17
C6 2/in4CK 0 9.72278e-17
C7 NET:6 0 3.32853e-16
C8 0/in7CK 0 2.92989e-17
C9 NET:8 0 1.01781e-16
C10 0/in16CK 0 2.86898e-17
C11 NET:10 0 8.44394e-17
C12 0/in21CK 0 1.12094e-17
C13 NET:12 0 5.73348e-17
C14 2/in1CK 0 1.16101e-17
C15 NET:14 0 5.6886e-17
C16 2/in9CK 0 1.1148e-16
C17 2/012CK 0 3.19177e-16
C18 2/in21CK 0 7.48407e-18
C19 NET:18 0 5.69509e-17
C20 2/in8CK 0 7.20822e-17
C21 0/in24CK 0 9.55e-18
C22 NET:21 0 1.14704e-16
C23 2/in7CK 0 1e-18
C24 NET:23 0 6.68907e-17
C25 2/06CK 0 2.49777e-17
C26 2/in5CK 0 3.79683e-17
C27 NET:26 0 1.40887e-16
C28 NET:27 0 1.33918e-16
C29 NET:28 0 7.33288e-16
C30 0/in9CK 0 9.79798e-18
C31 NET:30 0 1.41993e-16
C32 NET:31 0 2.05486e-16
C33 0/in19CK 0 1.44065e-17
C34 NET:33 0 6.97787e-17
C35 0/in17CK 0 4.51782e-17
C36 NET:35 0 1.81153e-16
C37 0/in12CK 0 1.79412e-17
C38 NET:37 0 1.38342e-16
C39 2/in2CK 0 6.89493e-18
C40 NET:39 0 8.07141e-17
C41 NET:40 0 2.02156e-16
C42 0/in1CK 0 1.84599e-17
C43 0/in20CK 0 2.09463e-17
C44 NET:43 0 8.9317e-17
C45 0/in2CK 0 1.27872e-17
C46 NET:45 0 9.96686e-17
C47 0/in4CK 0 1.49698e-17
C48 NET:47 0 7.46867e-17
C49 NET:48 0 1.11477e-16
C50 NET:49 0 1.03228e-15
C51 2/in20CK 0 1.45717e-17
C52 NET:51 0 9.34584e-17
C53 0/in3CK 0 7.37524e-18
C54 NET:53 0 5.97154e-17
C55 2/in14CK 0 3.65276e-17
C56 2/in12CK 0 3.41546e-17
C57 2/in15CK 0 1.62634e-16
C58 NET:57 0 3.08798e-16
C59 NET:58 0 1.129e-16
C60 NET:59 0 9.06643e-17
C61 NET:60 0 5.7332e-17
C62 NET:61 0 1.50484e-16
C63 NET:62 0 9.23849e-16
C64 NET:63 0 1.36417e-16
C65 NET:64 0 8.23364e-17
C66 NET:65 0 6.83134e-17
C67 NET:66 0 3.92635e-16
C68 NET:67 0 2.96047e-16
C69 2/216CK 0 1.83591e-17
C70 NET:69 0 4.83292e-17
C71 2/317CK 0 4.88338e-17
C72 0/324CK 0 1.63348e-17
C73 0/019CK 0 3.52747e-17
C74 NET:73 0 4.13956e-16
C75 0/224CK 0 7.00454e-18
C76 NET:75 0 1.56542e-16
C77 NET:76 0 1.63345e-16
C78 0/018CK 0 9.44333e-18
C79 NET:78 0 5.46052e-17
C80 0/118CK 0 5.92591e-18
C81 NET:80 0 1.01053e-16
C82 NET:81 0 5.34257e-16
C83 NET:82 0 5.36499e-16
C84 0/124CK 0 7.14725e-18
C85 NET:84 0 6.58617e-17
C86 2/316CK 0 9.64092e-18
C87 NET:86 0 6.05422e-17
C88 NET:87 0 6.47935e-16
C89 2/010CK 0 1e-18
C90 NET:89 0 1.14821e-16
C91 NET:90 0 2.62051e-16
C92 2/110CK 0 1.27396e-16
C93 2/018CK 0 2.9156e-17
C94 2/016CK 0 1.80365e-17
C95 NET:94 0 1.67844e-16
C96 2/011CK 0 1e-18
C97 NET:96 0 9.27414e-17
C98 2/017CK 0 8.9802e-17
C99 2/09CK 0 2.69911e-17
C100 NET:99 0 2.90594e-16
C101 2/112CK 0 1.28001e-17
C102 NET:101 0 7.21005e-17
C103 2/013CK 0 8.24177e-17
C104 2/215CK 0 1.08472e-16
C105 NET:104 0 2.04858e-16
C106 NET:105 0 4.09972e-16
C107 NET:106 0 1.69944e-16
C108 NET:107 0 7.73553e-16
C109 NET:108 0 8.56711e-16
C110 2/310CK 0 1e-18
C111 NET:110 0 7.99873e-17
C112 2/211CK 0 1.15822e-17
C113 NET:112 0 9.16647e-17
C114 NET:113 0 1.72703e-16
C115 2/217CK 0 3.23652e-17
C116 NET:115 0 2.48483e-16
C117 2/117CK 0 1.16698e-17
C118 NET:117 0 3.36209e-17
C119 2/in10CK 0 1.37277e-17
C120 NET:119 0 7.86392e-17
C121 2/in18CK 0 1.20129e-17
C122 NET:121 0 9.16443e-17
C123 2/36CK 0 3.49796e-17
C124 2/in3CK 0 1.84871e-16
C125 NET:124 0 2.35517e-16
C126 2/in11CK 0 1.19512e-17
C127 NET:126 0 8.83904e-17
C128 2/in17CK 0 1.59108e-17
C129 NET:128 0 9.7689e-17
C130 NET:129 0 3.83876e-16
C131 2/in6CK 0 4.21694e-18
C132 NET:131 0 4.55475e-17
C133 NET:132 0 1.38496e-16
C134 2/16CK 0 1e-18
C135 NET:134 0 6.18628e-17
C136 2/213CK 0 1.54381e-17
C137 NET:136 0 1.43657e-16
C138 NET:137 0 2.60341e-17
C139 NET:138 0 5.25342e-16
C140 NET:139 0 2.47793e-16
C141 NET:140 0 1.83204e-16
C142 2/in0CK 0 8.85768e-17
C143 2/210CK 0 1.61505e-17
C144 2/26CK 0 4.91875e-17
C145 NET:144 0 1.43627e-16
C146 2/07CK 0 2.39739e-17
C147 2/37CK 0 8.94325e-18
C148 NET:147 0 4.98463e-17
C149 2/17CK 0 6.00976e-17
C150 2/39CK 0 1.01486e-16
C151 NET:150 0 3.73647e-16
C152 NET:151 0 2.31649e-16
C153 2/312CK 0 6.64237e-17
C154 2/113CK 0 4.19086e-17
C155 NET:154 0 3.2454e-16
C156 2/220CK 0 2.17645e-17
C157 2/212CK 0 1.99754e-16
C158 2/221CK 0 1e-18
C159 NET:158 0 6.22233e-17
C160 2/in24CK 0 1e-18
C161 NET:160 0 5.43858e-17
C162 NET:161 0 5.33529e-16
C163 2/321CK 0 1.56148e-17
C164 NET:163 0 1.2229e-16
C165 NET:164 0 1.81931e-16
C166 NET:165 0 1.25899e-16
C167 NET:166 0 1.58542e-15
C168 NET:167 0 1.2464e-16
C169 NET:168 0 7.32109e-18
C170 NET:169 0 3.76522e-16
C171 1/in18CK 0 5.53392e-17
C172 NET:171 0 4.37627e-16
C173 1/in21CK 0 4.50436e-17
C174 NET:173 0 1.10039e-16
C175 0/37CK 0 1.37426e-17
C176 NET:175 0 4.06899e-17
C177 0/218CK 0 9.87633e-18
C178 NET:177 0 3.04536e-17
C179 NET:178 0 3.74162e-16
C180 0/19CK 0 3.18867e-17
C181 0/39CK 0 1.71995e-16
C182 NET:181 0 5.40743e-16
C183 0/29CK 0 7.50679e-18
C184 NET:183 0 8.99902e-17
C185 NET:184 0 4.24472e-16
C186 1/in14CK 0 9.74507e-18
C187 NET:186 0 1.15028e-16
C188 1/in17CK 0 1e-18
C189 NET:188 0 2.37613e-17
C190 1/in10CK 0 3.52327e-17
C191 1/in15CK 0 1.63718e-17
C192 NET:191 0 3.46003e-17
C193 1/in20CK 0 3.26273e-16
C194 0/09CK 0 2.04285e-16
C195 NET:194 0 2.48092e-16
C196 0/316CK 0 2.05381e-17
C197 NET:196 0 9.50007e-17
C198 1/in16CK 0 1.62377e-17
C199 NET:198 0 1.15108e-16
C200 NET:199 0 3.55947e-16
C201 NET:200 0 4.57144e-17
C202 NET:201 0 3.21744e-16
C203 NET:202 0 9.01822e-16
C204 NET:203 0 2.87523e-16
C205 0/25CK 0 1.63663e-17
C206 NET:205 0 1.17296e-16
C207 1/in13CK 0 4.97514e-18
C208 NET:207 0 1.41994e-16
C209 0/36CK 0 7.16733e-18
C210 NET:209 0 3.83438e-17
C211 NET:210 0 2.23948e-16
C212 NET:211 0 1.24168e-16
C213 NET:212 0 2.42127e-16
C214 Driver 0 4.17054e-17
CC1 0/39CK 0 4.78582e-17
CC2 2/210CK 0 2.79526e-18
CC3 2/212CK 0 5.82632e-18
CC4 2/212CK 0 2.59531e-17
CC5 NET:161 0 2.56437e-21
CC6 NET:181 0 2.13795e-16
CC7 NET:166 0 5.28001e-17
CC8 NET:166 0 7.5392e-16
CC9 NET:112 0 2.10615e-18
CC10 NET:158 0 1.20974e-18
CC11 NET:165 0 1.24166e-18
CC12 0/324CK 0 2.54731e-18
CC13 0/324CK 0 1.02947e-18
CC14 NET:76 0 5.50141e-17
CC15 NET:82 0 1.5635e-17
CC16 NET:78 0 1.92663e-20
CC17 NET:80 0 7.64831e-18
CC18 NET:81 0 2.7568e-16
CC19 NET:178 0 3.513e-18
CC20 NET:173 0 2.03528e-18
CC21 NET:175 0 5.01936e-18
CC22 NET:177 0 8.54066e-18
CC23 0/in10CK 0 6.10712e-18
CC24 0/in11CK 0 9.82708e-18
CC25 0/in16CK 0 1.01659e-19
CC26 NET:87 0 1.95859e-18
CC27 NET:181 0 9.51144e-19
CC28 NET:3 0 1.7496e-16
CC29 NET:63 0 1.15742e-16
CC30 NET:62 0 5.32404e-17
CC31 NET:166 0 3.1733e-19
CC32 Driver 0 1.31738e-18
CC33 0/in10CK 0 4.21866e-19
CC34 0/in16CK 0 3.90284e-18
CC35 0/in7CK 0 1.45487e-18
CC36 NET:169 0 1.24828e-18
CC37 NET:212 0 5.89216e-18
CC38 NET:6 0 5.56177e-19
CC39 NET:203 0 5.88201e-17
CC40 NET:67 0 4.14839e-17
CC41 NET:63 0 1.04524e-17
CC42 NET:62 0 1.78972e-18
CC43 NET:209 0 4.23697e-19
CC44 0/in11CK 0 4.64588e-20
CC45 0/in7CK 0 7.00228e-19
CC46 NET:73 0 3.10568e-18
CC47 NET:66 0 9.28829e-22
CC48 NET:169 0 2.57077e-19
CC49 NET:202 0 2.00113e-16
CC50 NET:3 0 3.63316e-19
CC51 NET:82 0 3.75422e-19
CC52 NET:63 0 8.43079e-19
CC53 0/in11CK 0 9.53503e-18
CC54 0/in7CK 0 7.32797e-19
CC55 1/in18CK 0 1.06714e-18
CC56 1/in19CK 0 1.23066e-20
CC57 1/in20CK 0 1.21986e-17
CC58 2/in15CK 0 1.42172e-19
CC59 NET:178 0 5.83321e-17
CC60 NET:194 0 4.1342e-18
CC61 NET:171 0 2.15118e-17
CC62 NET:2 0 1.10284e-19
CC63 NET:8 0 3.53426e-19
CC64 NET:31 0 1.69002e-20
CC65 NET:173 0 2.3032e-18
CC66 NET:3 0 5.2104e-17
CC67 NET:63 0 2.62028e-17
CC68 NET:62 0 9.88245e-17
CC69 NET:49 0 1.15476e-17
CC70 NET:49 0 5.36113e-18
CC71 NET:14 0 1.40208e-18
CC72 NET:37 0 1.13132e-17
CC73 NET:39 0 3.30485e-19
CC74 NET:51 0 2.02204e-18
CC75 NET:53 0 5.90084e-18
CC76 NET:43 0 9.17794e-19
CC77 NET:45 0 2.62599e-18
CC78 0/39CK 0 3.94253e-18
CC79 NET:178 0 4.00711e-19
CC80 NET:184 0 6.39737e-19
CC81 NET:181 0 2.25162e-16
CC82 NET:166 0 6.3759e-16
CC83 NET:166 0 4.7743e-17
CC84 0/09CK 0 1.10499e-19
CC85 0/in7CK 0 5.44674e-19
CC86 1/in19CK 0 9.70062e-17
CC87 NET:171 0 1.23159e-17
CC88 NET:65 0 7.43729e-20
CC89 NET:3 0 5.3688e-17
CC90 NET:63 0 2.17366e-18
CC91 NET:205 0 1.07077e-19
CC92 0/in16CK 0 3.67082e-19
CC93 0/in16CK 0 3.67082e-19
CC94 0/in7CK 0 3.67082e-19
CC95 0/in7CK 0 3.67082e-19
CC96 NET:3 0 1.5865e-16
CC97 NET:3 0 1.55292e-16
CC98 NET:63 0 4.99008e-17
CC99 NET:63 0 4.99008e-17
CC100 NET:62 0 3.46234e-17
CC101 NET:62 0 1.76451e-16
CC102 NET:201 0 7.20182e-18
CC103 NET:198 0 2.12911e-19
CC104 2/012CK 0 2.73408e-17
CC105 NET:30 0 4.00272e-20
CC106 NET:107 0 3.06643e-17
CC107 NET:94 0 3.23587e-20
CC108 2/017CK 0 3.37134e-19
CC109 2/212CK 0 3.92793e-21
CC110 NET:107 0 8.47861e-17
CC111 NET:105 0 1.61817e-16
CC112 NET:82 0 3.58275e-17
CC113 2/113CK 0 2.1733e-19
CC114 2/212CK 0 3.04954e-20
CC115 NET:161 0 2.08544e-17
CC116 NET:87 0 2.04046e-17
CC117 NET:166 0 1.38511e-18
CC118 NET:89 0 2.96293e-18
CC119 NET:89 0 6.10035e-18
CC120 NET:112 0 7.31079e-20
CC121 NET:108 0 1.18684e-17
CC122 NET:150 0 2.70329e-17
CC123 NET:150 0 4.36932e-17
CC124 2/210CK 0 2.00649e-18
CC125 2/in3CK 0 1.06035e-17
CC126 NET:124 0 4.30113e-18
CC127 NET:129 0 2.29744e-17
CC128 NET:138 0 5.59529e-17
CC129 NET:117 0 9.85531e-20
CC130 NET:119 0 8.37424e-19
CC131 NET:131 0 4.16479e-18
CC132 NET:126 0 9.40029e-19
CC133 NET:128 0 6.20486e-20
CC134 NET:139 0 3.05675e-18
CC135 2/210CK 0 5.60032e-20
CC136 NET:87 0 3.72751e-18
CC137 NET:108 0 2.72721e-17
CC138 NET:166 0 1.71625e-19
CC139 NET:166 0 4.07543e-18
CC140 NET:112 0 1.46289e-19
CC141 NET:112 0 6.45095e-18
CC142 2/012CK 0 9.62613e-18
CC143 2/018CK 0 1.00246e-18
CC144 2/217CK 0 1.20441e-20
CC145 NET:129 0 8.34984e-20
CC146 NET:138 0 8.68997e-17
CC147 NET:138 0 1.97412e-17
CC148 NET:107 0 1.1677e-16
CC149 NET:89 0 1.42697e-20
CC150 NET:119 0 2.44145e-19
CC151 NET:134 0 4.53735e-18
CC152 NET:136 0 2.47927e-19

.tran 0.1ps 5ps
.option method=gear2
*.option method=trap
*.plot tran V(2) V(0) V(1) I(Res1) I(Cap2) I(VDD)
.plot tran V(0/09CK)
.debug 1
