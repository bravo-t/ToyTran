vvdd vdd 0 0.81
.global vss
vvss vss 0 0
.temp 0
******************************************
* Start: Voltage Sources
******************************************
* voltage source for NET (victim)
* rise slew = 0.08 (lib units); trip points = (0.3 - 0.7); derate = 0.5
* The signal at NET is switching at 4 (delay trip point 0.5).
vNET NET 0 pwl(0.0ns    0
+       3.952006ns      0
+       3.962006ns      0.0405
+       3.972006ns      0.135614
+       3.982006ns      0.243
+       3.992006ns      0.337618
+       4.002006ns      0.421906
+       4.012006ns      0.497834
+       4.022006ns      0.567
+       4.032006ns      0.630694
+       4.042006ns      0.68996
+       4.052006ns      0.745643
+       4.062006ns      0.798429
+       4.072006ns      0.81)
* fall slew = 0.08 (lib units); trip points = (0.7 - 0.3); derate = 0.5
* The signal at NET is switching at 4 (delay trip point 0.5).
*vNET NET 0 pwl(0.0ns   0.81
*+      3.952006ns      0.81
*+      3.962006ns      0.7695
*+      3.972006ns      0.674386
*+      3.982006ns      0.567
*+      3.992006ns      0.472382
*+      4.002006ns      0.388094
*+      4.012006ns      0.312166
*+      4.022006ns      0.243
*+      4.032006ns      0.179306
*+      4.042006ns      0.12004
*+      4.052006ns      0.064357
*+      4.062006ns      0.011571
*+      4.072006ns      0)
******************************************
* End: Voltage Sources
******************************************
******************************************
* Start: Victim Nets
******************************************
* Timing arc net : (victim) NET
* driver pin 'NET'.
*The net NET has 0 noise injecting aggressor.
* resistors(s) for net 'NET'.
r00000  NET     NET:142 0.397256
r00001  IN      NET:20  0.01
r00002  IN      NET:21  8
r00003  IN      NET:44  0.295909
r00004  IN      NET:45  0.209545
r00005  NET:3   NET:4   14.95
r00006  NET:3   NET:30  0.14528
r00007  NET:4   NET:32  0.647156
r00008  NET:5   NET:32  7.38843
r00009  NET:5   NET:33  0.647122
r00010  NET:6   NET:33  45.7831
r00011  NET:6   NET:34  2.81763
r00012  NET:7   NET:34  4.76508
r00013  NET:7   NET:35  2.8199
r00014  NET:8   NET:35  48.9103
r00015  NET:8   NET:36  0.647104
r00016  NET:9   NET:36  4.77408
r00017  NET:9   NET:37  0.647057
r00018  NET:10  NET:37  47.796
r00019  NET:10  NET:38  0.646798
r00020  NET:11  NET:38  4.76499
r00021  NET:11  NET:39  0.646777
r00022  NET:12  NET:28  0.210469
r00023  NET:12  NET:29  47.8676
r00024  NET:13  NET:28  0.210469
r00025  NET:14  NET:15  2.07521
r00026  NET:14  NET:26  0.212246
r00027  NET:15  NET:27  0.210415
r00028  NET:16  NET:27  0.210415
r00029  NET:17  NET:25  0.213884
r00030  NET:18  NET:22  0.210581
r00031  NET:19  NET:21  0.197538
r00032  NET:21  NET:22  2
r00033  NET:21  NET:43  0.197538
r00034  NET:22  NET:23  0.149161
r00035  NET:23  NET:24  2
r00036  NET:23  NET:42  0.210581
r00037  NET:24  NET:25  0.356473
r00038  NET:24  NET:41  0.213884
r00039  NET:25  NET:26  2
r00040  NET:26  NET:40  0.212246
r00041  NET:27  NET:28  2
r00042  NET:29  NET:30  2.25
r00043  NET:30  NET:31  0.266113
r00044  NET:39  NET:182 48.8337
r00045  NET:44  NET:46  12.733
r00046  NET:47  NET:77  0.246745
r00047  NET:47  NET:185 1.26152
r00048  NET:48  NET:49  31.0763
r00049  NET:48  NET:79  0.145508
r00050  NET:49  NET:86  0.645833
r00051  NET:50  NET:86  14.192
r00052  NET:50  NET:87  0.645879
r00053  NET:51  NET:87  39.3318
r00054  NET:51  NET:88  0.646699
r00055  NET:52  NET:88  4.76558
r00056  NET:52  NET:89  0.646738
r00057  NET:53  NET:89  47.8331
r00058  NET:53  NET:90  0.646729
r00059  NET:54  NET:90  4.75863
r00060  NET:54  NET:91  0.64672
r00061  NET:55  NET:91  48.8442
r00062  NET:55  NET:92  0.646725
r00063  NET:56  NET:92  4.76561
r00064  NET:56  NET:93  0.646814
r00065  NET:57  NET:93  48.3242
r00066  NET:57  NET:94  0.647411
r00067  NET:58  NET:94  8.41975
r00068  NET:58  NET:95  0.647513
r00069  NET:59  NET:95  45.1789
r00070  NET:59  NET:96  0.647417
r00071  NET:60  NET:96  4.76676
r00072  NET:60  NET:97  0.647585
r00073  NET:61  NET:97  47.8358
r00074  NET:61  NET:98  0.64764
r00075  NET:62  NET:98  4.76525
r00076  NET:62  NET:99  0.647638
r00077  NET:63  NET:99  48.8473
r00078  NET:63  NET:100 0.647632
r00079  NET:64  NET:100 4.76554
r00080  NET:64  NET:101 0.647485
r00081  NET:65  NET:101 48.3242
r00082  NET:65  NET:102 0.647346
r00083  NET:66  NET:102 4.76318
r00084  NET:66  NET:103 0.647259
r00085  NET:67  NET:103 48.8774
r00086  NET:67  NET:104 0.646803
r00087  NET:68  NET:70  0.996201
r00088  NET:68  NET:81  0.246225
r00089  NET:69  NET:71  47.144
r00090  NET:69  NET:83  0.145386
r00091  NET:70  NET:104 4.75979
r00092  NET:71  NET:107 0.647256
r00093  NET:72  NET:107 5.27938
r00094  NET:72  NET:108 0.646945
r00095  NET:73  NET:108 48.8115
r00096  NET:73  NET:109 0.646671
r00097  NET:74  NET:109 4.7595
r00098  NET:74  NET:187 0.646242
r00099  NET:75  NET:76  0.615115
r00100  NET:75  NET:78  53.5251
r00101  NET:76  NET:77  2.25
r00102  NET:77  NET:84  0.246745
r00103  NET:78  NET:79  2.25
r00104  NET:79  NET:85  0.266666
r00105  NET:80  NET:81  2.25
r00106  NET:80  NET:82  9.50556
r00107  NET:81  NET:105 0.246225
r00108  NET:82  NET:83  2.25
r00109  NET:83  NET:106 0.266293
r00110  NET:110 NET:111 4.76443
r00111  NET:110 NET:188 0.647407
r00112  NET:111 NET:158 0.64742
r00113  NET:112 NET:158 48.8957
r00114  NET:112 NET:159 0.647873
r00115  NET:113 NET:159 8.4305
r00116  NET:113 NET:160 0.647752
r00117  NET:114 NET:160 37.3264
r00118  NET:114 NET:161 0.649203
r00119  NET:115 NET:161 11.6129
r00120  NET:115 NET:162 0.649376
r00121  NET:116 NET:162 48.8509
r00122  NET:116 NET:163 0.647353
r00123  NET:117 NET:163 4.76426
r00124  NET:117 NET:164 0.647295
r00125  NET:118 NET:164 48.4193
r00126  NET:118 NET:165 0.647106
r00127  NET:119 NET:165 4.76392
r00128  NET:119 NET:166 0.646999
r00129  NET:120 NET:166 48.7806
r00130  NET:120 NET:167 0.646806
r00131  NET:121 NET:167 4.76292
r00132  NET:121 NET:168 0.647032
r00133  NET:122 NET:168 47.7448
r00134  NET:122 NET:169 0.647787
r00135  NET:123 NET:124 48.4802
r00136  NET:123 NET:169 4.29407
r00137  NET:124 NET:151 0.17747
r00138  NET:125 NET:127 1.01609
r00139  NET:125 NET:149 0.245923
r00140  NET:126 NET:151 0.266206
r00141  NET:127 NET:128 26.7862
r00142  NET:128 NET:171 0.647091
r00143  NET:129 NET:171 4.76627
r00144  NET:129 NET:172 0.647055
r00145  NET:130 NET:132 1.0155
r00146  NET:130 NET:153 0.246207
r00147  NET:131 NET:155 0.177636
r00148  NET:131 NET:172 48.1221
r00149  NET:132 NET:133 27.2888
r00150  NET:133 NET:175 0.646133
r00151  NET:134 NET:175 4.75945
r00152  NET:134 NET:176 0.644717
r00153  NET:135 NET:136 0.992394
r00154  NET:135 NET:157 0.24741
r00155  NET:136 NET:176 53.3281
r00156  NET:137 NET:147 0.198013
r00157  NET:137 NET:156 24.7839
r00158  NET:138 NET:139 2.49423
r00159  NET:138 NET:146 0.198069
r00160  NET:139 NET:145 0.198165
r00161  NET:140 NET:145 0.198165
r00162  NET:141 NET:144 0.197801
r00163  NET:142 NET:143 0.197691
r00164  NET:143 NET:144 2
r00165  NET:143 NET:181 0.197691
r00166  NET:144 NET:145 2
r00167  NET:144 NET:180 0.197801
r00168  NET:146 NET:147 2
r00169  NET:146 NET:179 0.198069
r00170  NET:147 NET:178 0.198013
r00171  NET:148 NET:149 2.25
r00172  NET:148 NET:150 6.3415
r00173  NET:149 NET:170 0.245923
r00174  NET:150 NET:151 2.25
r00175  NET:152 NET:153 2.25
r00176  NET:152 NET:154 9.52006
r00177  NET:153 NET:173 0.246207
r00178  NET:154 NET:155 2.25
r00179  NET:155 NET:174 0.266454
r00180  NET:156 NET:157 2.25
r00181  NET:157 NET:177 0.24741
r00182  NET:182 NET:183 0.646297
r00183  NET:183 NET:184 0.01
r00184  NET:184 NET:189 3.418
r00185  NET:185 NET:189 17.6028
r00186  NET:186 NET:187 0.01
r00187  NET:187 NET:190 17.0099
r00188  NET:188 NET:190 31.326
* ground capacitors(s) for net 'NET'.
c00000  NET     0       1.71203e-17
c00001  IN      0       1e-21
c00002  NET:3   0       7.02428e-16
c00003  NET:4   0       3.1394e-17
c00004  NET:5   0       4.19261e-17
c00005  NET:6   0       1.64347e-16
c00006  NET:7   0       1.1184e-16
c00007  NET:8   0       2.54801e-17
c00008  NET:9   0       4.34037e-17
c00009  NET:10  0       2.806e-17
c00010  NET:11  0       2.02625e-17
c00011  NET:12  0       2.67001e-15
c00012  NET:13  0       8.5174e-18
c00013  NET:14  0       7.43585e-18
c00014  NET:15  0       1.23585e-16
c00015  NET:16  0       8.78004e-18
c00016  NET:17  0       7.29308e-17
c00017  NET:18  0       3.75886e-17
c00018  NET:19  0       3.67661e-17
c00019  NET:20  0       1e-21
c00020  NET:21  0       1e-21
c00021  NET:22  0       1e-21
c00022  NET:23  0       1e-21
c00023  NET:24  0       1e-21
c00024  NET:25  0       1e-21
c00025  NET:26  0       1e-21
c00026  NET:27  0       1e-21
c00027  NET:28  0       1e-21
c00028  NET:29  0       6.25489e-17
c00029  NET:30  0       1e-21
c00030  NET:31  0       1e-21
c00031  NET:32  0       3.51951e-16
c00032  NET:33  0       2.3972e-15
c00033  NET:34  0       2.2373e-16
c00034  NET:35  0       2.50606e-15
c00035  NET:36  0       2.37006e-16
c00036  NET:37  0       2.25234e-15
c00037  NET:38  0       2.18224e-16
c00038  NET:39  0       2.05511e-15
c00039  NET:40  0       1e-21
c00040  NET:41  0       1e-21
c00041  NET:42  0       1e-21
c00042  NET:43  0       1e-21
c00043  NET:44  0       1e-21
c00044  NET:45  0       1e-21
c00045  NET:46  0       1e-21
c00046  NET:47  0       6.29598e-17
c00047  NET:48  0       1.45351e-15
c00048  NET:49  0       4.61162e-17
c00049  NET:50  0       3.38459e-17
c00050  NET:51  0       4.28981e-17
c00051  NET:52  0       2.83837e-17
c00052  NET:53  0       4.83087e-17
c00053  NET:54  0       4.48402e-17
c00054  NET:55  0       2.54198e-17
c00055  NET:56  0       4.59715e-17
c00056  NET:57  0       2.11754e-17
c00057  NET:58  0       2.73658e-17
c00058  NET:59  0       3.43912e-17
c00059  NET:60  0       2.32463e-17
c00060  NET:61  0       2.38769e-17
c00061  NET:62  0       3.17397e-17
c00062  NET:63  0       2.23711e-17
c00063  NET:64  0       1.81073e-17
c00064  NET:65  0       2.89202e-17
c00065  NET:66  0       2.48029e-17
c00066  NET:67  0       2.71783e-17
c00067  NET:68  0       2.83516e-17
c00068  NET:69  0       1.97422e-15
c00069  NET:70  0       2.89482e-17
c00070  NET:71  0       2.63811e-17
c00071  NET:72  0       3.32014e-17
c00072  NET:73  0       3.43147e-17
c00073  NET:74  0       3.30363e-17
c00074  NET:75  0       2.55994e-15
c00075  NET:76  0       5.91046e-17
c00076  NET:77  0       1e-21
c00077  NET:78  0       4.22307e-17
c00078  NET:79  0       1e-21
c00079  NET:80  0       4.24003e-16
c00080  NET:81  0       1e-21
c00081  NET:82  0       4.46809e-17
c00082  NET:83  0       1e-21
c00083  NET:84  0       1e-21
c00084  NET:85  0       1e-21
c00085  NET:86  0       7.1476e-16
c00086  NET:87  0       1.94897e-15
c00087  NET:88  0       2.63299e-16
c00088  NET:89  0       2.51879e-15
c00089  NET:90  0       2.30354e-16
c00090  NET:91  0       2.38639e-15
c00091  NET:92  0       2.44269e-16
c00092  NET:93  0       2.02967e-15
c00093  NET:94  0       3.65955e-16
c00094  NET:95  0       2.03034e-15
c00095  NET:96  0       2.49971e-16
c00096  NET:97  0       2.15352e-15
c00097  NET:98  0       2.39039e-16
c00098  NET:99  0       2.17172e-15
c00099  NET:100 0       2.56951e-16
c00100  NET:101 0       2.15317e-15
c00101  NET:102 0       2.20231e-16
c00102  NET:103 0       2.26895e-15
c00103  NET:104 0       2.32652e-16
c00104  NET:105 0       1e-21
c00105  NET:106 0       1e-21
c00106  NET:107 0       2.66025e-16
c00107  NET:108 0       2.1283e-15
c00108  NET:109 0       2.15215e-16
c00109  NET:110 0       2.46923e-16
c00110  NET:111 0       2.44991e-17
c00111  NET:112 0       2.18178e-17
c00112  NET:113 0       1.88531e-17
c00113  NET:114 0       2.05915e-17
c00114  NET:115 0       1.71311e-17
c00115  NET:116 0       2.26275e-17
c00116  NET:117 0       2.35542e-17
c00117  NET:118 0       1.90929e-17
c00118  NET:119 0       2.35415e-17
c00119  NET:120 0       3.4933e-17
c00120  NET:121 0       1.36222e-17
c00121  NET:122 0       1.61697e-17
c00122  NET:123 0       2.76355e-17
c00123  NET:124 0       1.70735e-15
c00124  NET:125 0       3.25949e-17
c00125  NET:126 0       2.42302e-17
c00126  NET:127 0       1.118e-15
c00127  NET:128 0       1.83155e-17
c00128  NET:129 0       1.92513e-17
c00129  NET:130 0       1.3296e-17
c00130  NET:131 0       1.7495e-17
c00131  NET:132 0       1.12857e-15
c00132  NET:133 0       3.86482e-17
c00133  NET:134 0       3.29075e-17
c00134  NET:135 0       7.37797e-17
c00135  NET:136 0       4.1878e-17
c00136  NET:137 0       5.02677e-18
c00137  NET:138 0       1.05054e-17
c00138  NET:139 0       1.35756e-16
c00139  NET:140 0       4.95052e-18
c00141  NET:142 0       2.07542e-17
c00142  NET:143 0       1e-21
c00143  NET:144 0       1e-21
c00144  NET:145 0       1e-21
c00145  NET:146 0       1e-21
c00146  NET:147 0       1e-21
c00147  NET:148 0       3.42674e-16
c00148  NET:149 0       1e-21
c00149  NET:150 0       4.07248e-17
c00150  NET:151 0       1e-21
c00151  NET:152 0       3.64425e-16
c00152  NET:153 0       1e-21
c00153  NET:154 0       5.50266e-17
c00154  NET:155 0       1e-21
c00155  NET:156 0       1.43649e-15
c00156  NET:157 0       1e-21
c00157  NET:158 0       1.8106e-15
c00158  NET:159 0       3.14823e-16
c00159  NET:160 0       1.33662e-15
c00160  NET:161 0       4.67178e-16
c00161  NET:162 0       1.54073e-15
c00162  NET:163 0       2.06386e-16
c00163  NET:164 0       1.61802e-15
c00164  NET:165 0       2.06135e-16
c00165  NET:166 0       1.72138e-15
c00166  NET:167 0       2.05918e-16
c00167  NET:168 0       1.72592e-15
c00168  NET:169 0       1.80301e-16
c00169  NET:170 0       1e-21
c00170  NET:171 0       2.12613e-16
c00171  NET:172 0       1.96559e-15
c00172  NET:173 0       1e-21
c00173  NET:174 0       1e-21
c00174  NET:175 0       2.16889e-16
c00175  NET:176 0       2.66337e-15
c00176  NET:177 0       1e-21
c00177  NET:178 0       1e-21
c00178  NET:179 0       1e-21
c00179  NET:180 0       1e-21
c00180  NET:181 0       1e-21
c00181  NET:182 0       2.16533e-17
c00182  NET:183 0       1.77729e-16
c00183  NET:184 0       1e-21
c00184  NET:185 0       7.54753e-16
c00185  NET:186 0       5.71459e-16
c00186  NET:187 0       1e-21
c00187  NET:188 0       1.0949e-15
c00188  NET:189 0       1e-21
c00189  NET:190 0       2.61867e-18
******************************************
* Grounded coupling capacitors for nets 'NET_AGGR'.
c00191  NET:69  0       1.03101e-16
c00192  NET:107 0       7.5775e-18
c00193  NET:108 0       3.05309e-18
c00194  NET:108 0       7.25944e-17
c00195  NET:109 0       1.37961e-17
c00196  NET:110 0       1.24499e-17
c00197  NET:158 0       6.42063e-17
c00198  NET:158 0       5.84005e-17
c00199  NET:158 0       4.9401e-17
c00200  NET:159 0       1.59459e-17
c00201  NET:159 0       1.59459e-17
c00202  NET:160 0       6.49589e-17
c00203  NET:160 0       3.48678e-17
c00204  NET:160 0       3.00911e-17
c00205  NET:161 0       2.54074e-17
c00206  NET:161 0       1.93905e-17
c00207  NET:162 0       5.89432e-17
c00208  NET:162 0       1.15864e-16
c00209  NET:162 0       5.69206e-17
c00210  NET:163 0       5.89331e-18
c00211  NET:163 0       5.89331e-18
c00212  NET:164 0       7.16858e-17
c00213  NET:164 0       7.16858e-17
c00214  NET:164 0       7.05868e-17
c00215  NET:186 0       2.14478e-17
c00216  NET:186 0       4.06835e-18
c00217  NET:186 0       5.35997e-18
c00218  NET:186 0       2.32209e-17
c00219  NET:188 0       1.10732e-16
c00220  IN 0 5.732e-15

* transient analysis
.tran 0.001ns 7.13ns

.plot tran result.V(IN) result.V(NET)
******************************************
* Start: Victim Measure Statements
******************************************
* .print voltage section:NB
.measure tran delay_IN_OUT
+ trig v(IN)=0.405 td = 1.498ns
+ targ v(OUT)=0.405
.measure tran wsd_tmp_slew_00000
+ trig v(IN)=0.243 td = 1.498ns
+ targ v(IN)=0.567
.measure tran delay_NET_IN
+ trig v(NET)=0.405 td = 2.88ns
+ targ v(IN)=0.405
.measure tran wsd_tmp_slew_00002
+ trig v(NET)=0.243 td = 2.88ns
+ targ v(NET)=0.567
******************************************
* End: Victim Measure Statements
******************************************
