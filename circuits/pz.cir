VVDD POS GND 5
RR1 POS N1 10
CC1 N1 GND 1m
RR2 N1 N2 10
CC2 N2 GND 1m
RR3 N2 N3 10
CC3 N3 GND 1m
RR4 N3 N4 10
CC4 N4 GND 1m
RR5 N4 N5 10
CC5 N5 GND 1m
RR6 N5 N6 10
CC6 N6 GND 1m
RR7 N6 GND 30

.debug 1
.pz V(N6) V(POS)
.option pzorder=5
